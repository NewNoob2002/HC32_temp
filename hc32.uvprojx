# Keil uVision project hc32.uvprojx, settings and files
target hc32 (6160000::V6.16::ARMCLANG)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32 +hex
  c flags: Optim=2 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: HC32F460,USE_DEVICE_DRIVER_LIB,__VFP_FP__
  c include: .\app;.\config;.\driver\inc;.\mcu_core;.\mcu_core\CMSIS\Include;.\FreeRTOS2;.\FreeRTOS2\include;.\FreeRTOS2\portable\GCC\ARM_CM4F
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group app
    ./app/: main.cpp
  group core
    ./mcu_core/: hc32f460.h startup_hc32f460.s system_hc32f460.c system_hc32f460.h
  group config
    ./config/: ddl_config.h hc32_common.h hc32_ddl.h
    ./FreeRTOS2/: FreeRTOSConfig.h
  group driver_ddl
    ./driver/src/: hc32f460_adc.c hc32f460_aes.c hc32f460_clk.c hc32f460_cmp.c hc32f460_crc.c hc32f460_event_port.c hc32f460_gpio.c hc32f460_i2c.c hc32f460_interrupts.c hc32f460_rtc.c hc32f460_spi.c hc32f460_sram.c hc32f460_swdt.c hc32f460_timer0.c hc32f460_timer6.c hc32f460_timera.c hc32f460_trng.c hc32f460_usart.c hc32f460_utility.c hc32f460_wdt.c hc32f460_ots.c hc32f460_pwc.c hc32f460_efm.c hc32f460_exint_nmi_swi.c
  group FreeRTOS
    ./FreeRTOS2/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS2/portable/MemMang/: heap_4.c
    ./FreeRTOS2/portable/GCC/ARM_CM4F/: port.c
